<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\field_emission_machine_IWDG_fix.ewp</path>
  </project>
  <batchBuild />
</workspace>
